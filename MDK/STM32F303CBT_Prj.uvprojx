# Keil uVision project STM32F303CBT_Prj.uvprojx, settings and files
target STM32F303CBT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303CBT_Prj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: STM32F303xC, ARM_MATH_CM4, __FPU_PRESENT = 1U
  c include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group USER
    ../Src/: main.c inits.c delay.c stm32f3xx_it.c VectCalc.c dfilt.c pi.c interrupts.c measurement.c motorcontrol.c Tims.c RLPsiDetect.c
  group MATH
    ../Src/: mymath.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 1.0.0
